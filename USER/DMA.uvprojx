# Keil uVision project DMA.uvprojx, settings and files
target DMA (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: DMA +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\HARDWARE\LCD;..\HARDWARE\KEY;..\HARDWARE\DMA;..\FWLIB\inc;..\HARDWARE\RELAY;..\HARDWARE\WIFI;..\HARDWARE\74HC4051;..\HARDWARE\ADS1220;..\SYSTEM\SPI;..\HARDWARE\ADS1256;..\HARDWARE\PWM;..\HARDWARE\IIC;..\HARDWARE\PVD;..\HARDWARE\24CXX
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/DMA/: dma.c
    ../HARDWARE/RELAY/: relay_control.c
    ../HARDWARE/WIFI/: wifi.c
    ../HARDWARE/74HC4051/: 74hc4051.c
    ../HARDWARE/ADS1256/: ADS1256.c
    ../HARDWARE/PWM/: PWM_CHECK.c
    ../HARDWARE/PVD/: pvd.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/24CXX/: 24cxx.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_dma.c stm32f4xx_gpio.c stm32f4xx_fsmc.c stm32f4xx_usart.c stm32f4xx_syscfg.c stm32f4xx_rcc.c stm32f4xx_adc.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_exti.c stm32f4xx_pwr.c
  group README
    ../: readme.txt
